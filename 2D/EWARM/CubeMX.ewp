# IAR project CubeMX.ewp, settings and files
configuration CubeMX (ARM, debug)
  General.OGChipSelectEditMenu: STM32L431CC ST STM32L431CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L431xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; source\include; source\include\defs; source\include\setup\evk\2d; source\include\setup\evk\distance_wide; source\include\setup\evk\fifo_fft_1rx_wide; source\include\setup\evk\fifo_fft_2rx_wide; source\include\setup\evk\fifo_iq_1rx_wide; source\include\setup\evk\fifo_iq_2rx_wide; source\include\setup\evk\motion_wide; source\lib\convbin\include; source\lib\dllsearch\include; source\lib\rs24g_bin_core\include; source\lib\rs24g_bin_platform\include; source\lib\rs24g_ctl_core\include; source\lib\rs24g_ctl_core\sc1233\include; source\lib\rs24g_ctl_setup_core\include; source\lib\rs24g_ctl_setup_core\include\local; source\lib\rs24g_ctl_setup_core\sc1233\include; source\lib\rs24g_ctl_setup_core\sc1233\include\local; source\lib\rs_ctl_dev\include; source\lib\rs_ctl_dev_evk\include; source\lib\rs_ctl_dev_poc\include; source\lib\rs_ctl_lib\include; source\lib\rs24g_2d_sc1233_core\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: source\include; source\include\defs; source\include\setup\evk\2d; source\include\setup\evk\distance_wide; source\include\setup\evk\fifo_fft_1rx_wide; source\include\setup\evk\fifo_fft_2rx_wide; source\include\setup\evk\fifo_iq_1rx_wide; source\include\setup\evk\fifo_iq_2rx_wide; source\include\setup\evk\motion_wide; source\lib\convbin\include; source\lib\dllsearch\include; source\lib\rs24g_bin_core\include; source\lib\rs24g_bin_platform\include; source\lib\rs24g_ctl_core\include; source\lib\rs24g_ctl_core\sc1233\include; source\lib\rs24g_ctl_setup_core\include; source\lib\rs24g_ctl_setup_core\include\local; source\lib\rs24g_ctl_setup_core\sc1233\include; source\lib\rs24g_ctl_setup_core\sc1233\include\local; source\lib\rs_ctl_dev\include; source\lib\rs_ctl_dev_evk\include; source\lib\rs_ctl_dev_poc\include; source\lib\rs_ctl_lib\include; source\lib\rs24g_2d_sc1233_core\include
  OBJCOPY.OOCOutputFile: CubeMX.hex
  ILINK.IlinkOutputFile: CubeMX.out
  ILINK.IlinkIcfFile: stm32l431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: CubeMX.ipcf
    source/lib/rs24g_2d_sc1233_core/: qsort1.c
  group Application/EWARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group src/source
    source/: rs24g_sample_sc1233.c
  group src/source/lib/dllsearch
    source/lib/dllsearch/: dllsearch.cpp
  group src/source/lib/rs24g_2d_sc1233_core
    source/lib/rs24g_2d_sc1233_core/: common_2d.c location.c location_debug.c rs24g_2d_sc1233_base.c rs24g_2d_sc1233_local.c rs24g_2d_sc1233_range.c rs24g_2d_sc1233_version.c rs_list.c
  group src/source/lib/rs24g_bin_core
    source/lib/rs24g_bin_core/: rs24g_bin.c rs24g_code2.c rs24g_code2_local.c
  group src/source/lib/rs24g_bin_platform
    source/lib/rs24g_bin_platform/: rs24g_bin_interface.c
  group src/source/lib/rs24g_ctl_core
    source/lib/rs24g_ctl_core/: rs24g_ctl_2rx.c rs24g_ctl_base.c rs24g_ctl_common.c rs24g_ctl_distance.c rs24g_ctl_fifo.c rs24g_ctl_motion.c rs24g_ctl_sensor_ctl_type.c rs24g_ctl_setup.c
  group src/source/lib/rs24g_ctl_core/sc1233
    source/lib/rs24g_ctl_core/sc1233/: rs24g_ctl_sc1233_version.c
  group src/source/lib/rs24g_ctl_setup_core
    source/lib/rs24g_ctl_setup_core/: rs24g_ctl_setup_base.c rs24g_ctl_setup_range.c setup_2d.c setup_bin.c setup_common.c setup_distance.c setup_distance_wide.c setup_fifo.c setup_fifo_fft_1rx_wide.c setup_fifo_fft_2rx_wide.c setup_fifo_iq_1rx_wide.c setup_fifo_iq_2rx_wide.c setup_motion.c setup_motion_wide.c
  group src/source/lib/rs24g_ctl_setup_core/sc1233
    source/lib/rs24g_ctl_setup_core/sc1233/: rs24g_ctl_setup_sc1233_version.c
  group src/source/lib/rs_ctl_dev
    source/lib/rs_ctl_dev/: rs_ctl_dev.c
  group src/source/lib/rs_ctl_dev_evk
    source/lib/rs_ctl_dev_evk/: rs_ctl_dev_evk.cpp rs_ftdi.cpp
  group src/source/lib/rs_ctl_dev_poc
    source/lib/rs_ctl_dev_poc/: rs_ctl_dev_poc.cpp rs_i2c.cpp
  group src/source/lib/rs_ctl_lib
    source/lib/rs_ctl_lib/: rs_ctl_cmd.c rs_ctl_cmd_sc1233.c rs_ctl_data.c rs_ctl_op.c rs_ctl_sensor_data.c
  group src/source/lib/rs_platform
    source/lib/rs_platform/: rs_mutex.cpp rs_sleep.cpp
