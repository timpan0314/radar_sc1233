# IAR project radar_2d.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F071CB ST STM32F071CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: source\include; source\include\defs; source\include\setup\evk\2d; source\include\setup\evk\distance_wide; source\include\setup\evk\fifo_fft_1rx_wide; source\include\setup\evk\fifo_fft_2rx_wide; source\include\setup\evk\fifo_iq_1rx_wide; source\include\setup\evk\fifo_iq_2rx_wide; source\include\setup\evk\motion_wide; source\lib\convbin\include; source\lib\dllsearch\include; source\lib\rs24g_bin_core\include; source\lib\rs24g_bin_platform\include; source\lib\rs24g_ctl_core\include; source\lib\rs24g_ctl_core\sc1233\include; source\lib\rs24g_ctl_setup_core\include; source\lib\rs24g_ctl_setup_core\include\local; source\lib\rs24g_ctl_setup_core\sc1233\include; source\lib\rs24g_ctl_setup_core\sc1233\include\local; source\lib\rs_ctl_dev\include; source\lib\rs_ctl_dev_evk\include; source\lib\rs_ctl_dev_poc\include; source\lib\rs_ctl_lib\include; STM32F0xx_HAL_Driver\Inc; STM32F0xx_HAL_Driver\Inc\Legacy; CMSIS\Core\Include; CMSIS\Core_A\Include; CMSIS\DSP\DSP_Lib_TestSuite\Common\JTest\inc; CMSIS\DSP\DSP_Lib_TestSuite\Common\JTest\inc\arr_desc; CMSIS\DSP\DSP_Lib_TestSuite\Common\JTest\inc\opt_arg; CMSIS\DSP\DSP_Lib_TestSuite\Common\JTest\inc\util; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\basic_math_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\complex_math_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\controller_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\fast_math_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\filtering_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\intrinsics_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\matrix_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\statistics_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\support_tests; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\templates; CMSIS\DSP\DSP_Lib_TestSuite\Common\inc\transform_tests; CMSIS\DSP\DSP_Lib_TestSuite\RefLibs\inc; CMSIS\DSP\Examples\ARM\arm_convolution_example; CMSIS\DSP\Examples\ARM\arm_fir_example; CMSIS\DSP\Examples\ARM\arm_graphic_equalizer_example; CMSIS\DSP\Examples\ARM\arm_linear_interp_example; CMSIS\DSP\Examples\ARM\arm_matrix_example; CMSIS\DSP\Examples\ARM\arm_signal_converge_example; CMSIS\DSP\Include; CMSIS\Device\ST\STM32F0xx\Include; CMSIS\Include; CMSIS\NN\Examples\ARM\arm_nn_examples\cifar10; CMSIS\NN\Examples\ARM\arm_nn_examples\cifar10\RTE\Compiler; CMSIS\NN\Examples\ARM\arm_nn_examples\cifar10\RTE\_ARMCM0; CMSIS\NN\Examples\ARM\arm_nn_examples\cifar10\RTE\_ARMCM3; CMSIS\NN\Examples\ARM\arm_nn_examples\cifar10\RTE\_ARMCM4_FP; CMSIS\NN\Examples\ARM\arm_nn_examples\cifar10\RTE\_ARMCM7_SP; CMSIS\NN\Examples\ARM\arm_nn_examples\gru; CMSIS\NN\Examples\ARM\arm_nn_examples\gru\RTE\Compiler; CMSIS\NN\Examples\ARM\arm_nn_examples\gru\RTE\_ARMCM0; CMSIS\NN\Examples\ARM\arm_nn_examples\gru\RTE\_ARMCM3; CMSIS\NN\Examples\ARM\arm_nn_examples\gru\RTE\_ARMCM4_FP; CMSIS\NN\Examples\ARM\arm_nn_examples\gru\RTE\_ARMCM7_SP; CMSIS\NN\Include; CMSIS\NN\NN_Lib_Tests\nn_test; CMSIS\NN\NN_Lib_Tests\nn_test\RTE\_ARMCM0; CMSIS\NN\NN_Lib_Tests\nn_test\RTE\_ARMCM3; CMSIS\NN\NN_Lib_Tests\nn_test\RTE\_ARMCM4_FP; CMSIS\NN\NN_Lib_Tests\nn_test\RTE\_ARMCM7_SP; CMSIS\NN\NN_Lib_Tests\nn_test\Ref_Implementations; CMSIS\RTOS\Template; CMSIS\RTOS2\Include; CMSIS\RTOS2\Template; user\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: radar_2d.out
  ILINK.IlinkIcfFile: radar_2d.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: radar_2d.ipcf
  group src/CMSIS/Core/Template/ARMv8-M
    CMSIS/Core/Template/ARMv8-M/: main_s.c tz_context.c
  group src/CMSIS/Core_A/Source
    CMSIS/Core_A/Source/: irq_ctrl_gic.c
  group src/CMSIS/Device/ST/STM32F0xx/Source/Templates
    CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group src/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm
    CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x6.s startup_stm32f030x8.s startup_stm32f030xc.s startup_stm32f031x6.s startup_stm32f038xx.s startup_stm32f042x6.s startup_stm32f048xx.s startup_stm32f051x8.s startup_stm32f058xx.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f071xb.s startup_stm32f072xb.s startup_stm32f078xx.s startup_stm32f091xc.s startup_stm32f098xx.s
  group src/CMSIS/Device/ST/STM32F0xx/Source/Templates/gcc
    CMSIS/Device/ST/STM32F0xx/Source/Templates/gcc/: startup_stm32f030x6.s startup_stm32f030x8.s startup_stm32f030xc.s startup_stm32f031x6.s startup_stm32f038xx.s startup_stm32f042x6.s startup_stm32f048xx.s startup_stm32f051x8.s startup_stm32f058xx.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f071xb.s startup_stm32f072xb.s startup_stm32f078xx.s startup_stm32f091xc.s startup_stm32f098xx.s
  group src/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar
    CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x6.s startup_stm32f030x8.s startup_stm32f030xc.s startup_stm32f031x6.s startup_stm32f038xx.s startup_stm32f042x6.s startup_stm32f048xx.s startup_stm32f051x8.s startup_stm32f058xx.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f071xb.s startup_stm32f072xb.s startup_stm32f078xx.s startup_stm32f091xc.s startup_stm32f098xx.s
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/JTest/src
    CMSIS/DSP/DSP_Lib_TestSuite/Common/JTest/src/: jtest_cycle.c jtest_dump_str_segments.c jtest_fw.c jtest_trigger_action.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/platform
    CMSIS/DSP/DSP_Lib_TestSuite/Common/platform/: system_ARMCM0.c system_ARMCM23.c system_ARMCM3.c system_ARMCM33.c system_ARMCM4.c system_ARMCM7.c system_ARMSC000.c system_ARMSC300.c system_ARMv8MBL.c system_ARMv8MML.c system_generic.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/platform/ARMCC
    CMSIS/DSP/DSP_Lib_TestSuite/Common/platform/ARMCC/: Retarget.c startup_armv6-m.s startup_armv7-m.s
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/platform/GCC
    CMSIS/DSP/DSP_Lib_TestSuite/Common/platform/GCC/: Retarget.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/: all_tests.c main.c math_helper.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/basic_math_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/basic_math_tests/: abs_tests.c add_tests.c basic_math_test_common_data.c basic_math_test_group.c dot_prod_tests.c mult_tests.c negate_tests.c offset_tests.c scale_tests.c shift_tests.c sub_tests.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/complex_math_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/complex_math_tests/: cmplx_conj_tests.c cmplx_dot_prod_tests.c cmplx_mag_squared_tests.c cmplx_mag_tests.c cmplx_mult_cmplx_tests.c cmplx_mult_real_test.c complex_math_test_common_data.c complex_math_test_group.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/controller_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/controller_tests/: controller_test_common_data.c controller_test_group.c pid_reset_tests.c pid_tests.c sin_cos_tests.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/fast_math_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/fast_math_tests/: fast_math_tests.c fast_math_tests_common_data.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/filtering_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/filtering_tests/: biquad_tests.c conv_tests.c correlate_tests.c filtering_test_common_data.c filtering_test_group.c fir_tests.c iir_tests.c lms_tests.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/intrinsics_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/intrinsics_tests/: intrinsics_tests.c intrinsics_tests_common_data.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/matrix_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/matrix_tests/: mat_add_tests.c mat_cmplx_mult_tests.c mat_init_tests.c mat_inverse_tests.c mat_mult_fast_tests.c mat_mult_tests.c mat_scale_tests.c mat_sub_tests.c mat_trans_tests.c matrix_test_common_data.c matrix_test_group.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/statistics_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/statistics_tests/: max_tests.c mean_tests.c min_tests.c power_tests.c rms_tests.c statistics_test_common_data.c statistics_test_group.c std_tests.c var_tests.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/support_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/support_tests/: copy_tests.c fill_tests.c support_test_common_data.c support_test_group.c x_to_y_tests.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/Common/src/transform_tests
    CMSIS/DSP/DSP_Lib_TestSuite/Common/src/transform_tests/: cfft_family_tests.c cfft_tests.c dct4_tests.c rfft_fast_tests.c rfft_tests.c transform_test_group.c transform_tests_common_data.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/BasicMathFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/BasicMathFunctions/: abs.c add.c dot_prod.c mult.c negate.c offset.c scale.c shift.c sub.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/ComplexMathFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/ComplexMathFunctions/: cmplx_conj.c cmplx_dot_prod.c cmplx_mag.c cmplx_mag_squared.c cmplx_mult_cmplx.c cmplx_mult_real.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/ControllerFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/ControllerFunctions/: pid.c sin_cos.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/FastMathFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/FastMathFunctions/: cos.c sin.c sqrt.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/FilteringFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/FilteringFunctions/: biquad.c conv.c correlate.c fir.c fir_decimate.c fir_interpolate.c fir_lattice.c fir_sparse.c iir_lattice.c lms.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/HelperFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/HelperFunctions/: mat_helper.c ref_helper.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/Intrinsics
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/Intrinsics/: intrinsics.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/MatrixFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/MatrixFunctions/: mat_add.c mat_cmplx_mult.c mat_inverse.c mat_mult.c mat_scale.c mat_sub.c mat_trans.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/StatisticsFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/StatisticsFunctions/: max.c mean.c min.c power.c rms.c std.c var.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/SupportFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/SupportFunctions/: copy.c fill.c fixed_to_fixed.c fixed_to_float.c float_to_fixed.c
  group src/CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/TransformFunctions
    CMSIS/DSP/DSP_Lib_TestSuite/RefLibs/src/TransformFunctions/: bitreversal.c cfft.c dct4.c rfft.c
  group src/CMSIS/DSP/Examples/ARM/arm_class_marks_example
    CMSIS/DSP/Examples/ARM/arm_class_marks_example/: arm_class_marks_example_f32.c
  group src/CMSIS/DSP/Examples/ARM/arm_convolution_example
    CMSIS/DSP/Examples/ARM/arm_convolution_example/: arm_convolution_example_f32.c math_helper.c
  group src/CMSIS/DSP/Examples/ARM/arm_dotproduct_example
    CMSIS/DSP/Examples/ARM/arm_dotproduct_example/: arm_dotproduct_example_f32.c
  group src/CMSIS/DSP/Examples/ARM/arm_fft_bin_example
    CMSIS/DSP/Examples/ARM/arm_fft_bin_example/: arm_fft_bin_data.c arm_fft_bin_example_f32.c
  group src/CMSIS/DSP/Examples/ARM/arm_fir_example
    CMSIS/DSP/Examples/ARM/arm_fir_example/: arm_fir_data.c arm_fir_example_f32.c math_helper.c
  group src/CMSIS/DSP/Examples/ARM/arm_graphic_equalizer_example
    CMSIS/DSP/Examples/ARM/arm_graphic_equalizer_example/: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c math_helper.c
  group src/CMSIS/DSP/Examples/ARM/arm_linear_interp_example
    CMSIS/DSP/Examples/ARM/arm_linear_interp_example/: arm_linear_interp_data.c arm_linear_interp_example_f32.c math_helper.c
  group src/CMSIS/DSP/Examples/ARM/arm_matrix_example
    CMSIS/DSP/Examples/ARM/arm_matrix_example/: arm_matrix_example_f32.c math_helper.c
  group src/CMSIS/DSP/Examples/ARM/arm_signal_converge_example
    CMSIS/DSP/Examples/ARM/arm_signal_converge_example/: arm_signal_converge_data.c arm_signal_converge_example_f32.c math_helper.c
  group src/CMSIS/DSP/Examples/ARM/arm_sin_cos_example
    CMSIS/DSP/Examples/ARM/arm_sin_cos_example/: arm_sin_cos_example_f32.c
  group src/CMSIS/DSP/Examples/ARM/arm_variance_example
    CMSIS/DSP/Examples/ARM/arm_variance_example/: arm_variance_example_f32.c
  group src/CMSIS/DSP/Source/BasicMathFunctions
    CMSIS/DSP/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q15.c arm_abs_q31.c arm_abs_q7.c arm_add_f32.c arm_add_q15.c arm_add_q31.c arm_add_q7.c arm_dot_prod_f32.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_dot_prod_q7.c arm_mult_f32.c arm_mult_q15.c arm_mult_q31.c arm_mult_q7.c arm_negate_f32.c arm_negate_q15.c arm_negate_q31.c arm_negate_q7.c arm_offset_f32.c arm_offset_q15.c arm_offset_q31.c arm_offset_q7.c arm_scale_f32.c arm_scale_q15.c arm_scale_q31.c arm_scale_q7.c arm_shift_q15.c arm_shift_q31.c arm_shift_q7.c arm_sub_f32.c arm_sub_q15.c arm_sub_q31.c arm_sub_q7.c
  group src/CMSIS/DSP/Source/CommonTables
    CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
  group src/CMSIS/DSP/Source/ComplexMathFunctions
    CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
  group src/CMSIS/DSP/Source/ControllerFunctions
    CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
  group src/CMSIS/DSP/Source/FastMathFunctions
    CMSIS/DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
  group src/CMSIS/DSP/Source/FilteringFunctions
    CMSIS/DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q15.c arm_conv_opt_q7.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q15.c arm_conv_partial_opt_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_partial_q7.c arm_conv_q15.c arm_conv_q31.c arm_conv_q7.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q15.c arm_correlate_opt_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_correlate_q7.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_init_q7.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q15.c arm_fir_q31.c arm_fir_q7.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_init_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_fir_sparse_q7.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
  group src/CMSIS/DSP/Source/MatrixFunctions
    CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group src/CMSIS/DSP/Source/StatisticsFunctions
    CMSIS/DSP/Source/StatisticsFunctions/: arm_max_f32.c arm_max_q15.c arm_max_q31.c arm_max_q7.c arm_mean_f32.c arm_mean_q15.c arm_mean_q31.c arm_mean_q7.c arm_min_f32.c arm_min_q15.c arm_min_q31.c arm_min_q7.c arm_power_f32.c arm_power_q15.c arm_power_q31.c arm_power_q7.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
  group src/CMSIS/DSP/Source/SupportFunctions
    CMSIS/DSP/Source/SupportFunctions/: arm_copy_f32.c arm_copy_q15.c arm_copy_q31.c arm_copy_q7.c arm_fill_f32.c arm_fill_q15.c arm_fill_q31.c arm_fill_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_float_to_q7.c arm_q15_to_float.c arm_q15_to_q31.c arm_q15_to_q7.c arm_q31_to_float.c arm_q31_to_q15.c arm_q31_to_q7.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c
  group src/CMSIS/DSP/Source/TransformFunctions
    CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group src/CMSIS/Lib/GCC
    CMSIS/Lib/GCC/: libarm_cortexM0l_math.a
  group src/CMSIS/Lib/IAR
    CMSIS/Lib/IAR/: iar_cortexM0b_math.a iar_cortexM0l_math.a
  group src/CMSIS/NN/Examples/ARM/arm_nn_examples/cifar10
    CMSIS/NN/Examples/ARM/arm_nn_examples/cifar10/: arm_nnexamples_cifar10.cpp
  group src/CMSIS/NN/Examples/ARM/arm_nn_examples/gru
    CMSIS/NN/Examples/ARM/arm_nn_examples/gru/: arm_nnexamples_gru.cpp
  group src/CMSIS/NN/NN_Lib_Tests/nn_test
    CMSIS/NN/NN_Lib_Tests/nn_test/: arm_nnexamples_nn_test.cpp
  group src/CMSIS/NN/NN_Lib_Tests/nn_test/Ref_Implementations
    CMSIS/NN/NN_Lib_Tests/nn_test/Ref_Implementations/: arm_convolve_HWC_q15_ref.c arm_convolve_HWC_q15_ref_nonsquare.c arm_convolve_HWC_q7_ref.c arm_convolve_HWC_q7_ref_nonsquare.c arm_depthwise_separable_conv_HWC_q7_ref.c arm_depthwise_separable_conv_HWC_q7_ref_nonsquare.c arm_fully_connected_mat_q7_vec_q15_opt_ref.c arm_fully_connected_mat_q7_vec_q15_ref.c arm_fully_connected_q15_opt_ref.c arm_fully_connected_q15_ref.c arm_fully_connected_q7_opt_ref.c arm_fully_connected_q7_ref.c arm_nn_mult_ref.c arm_pool_ref.c arm_relu_ref.c
  group src/CMSIS/NN/Source/ActivationFunctions
    CMSIS/NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu_q15.c arm_relu_q7.c
  group src/CMSIS/NN/Source/ConvolutionFunctions
    CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c
  group src/CMSIS/NN/Source/FullyConnectedFunctions
    CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c
  group src/CMSIS/NN/Source/NNSupportFunctions
    CMSIS/NN/Source/NNSupportFunctions/: arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c
  group src/CMSIS/NN/Source/PoolingFunctions
    CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
  group src/CMSIS/NN/Source/SoftmaxFunctions
    CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q15.c arm_softmax_q7.c
  group src/CMSIS/RTOS2/Source
    CMSIS/RTOS2/Source/: os_systick.c os_tick_gtim.c os_tick_ptim.c
  group src/CMSIS/RTOS2/Template
    CMSIS/RTOS2/Template/: cmsis_os1.c
  group src/source
    source/: rs24g_sample_sc1233.c
  group src/source/lib/dllsearch
    source/lib/dllsearch/: dllsearch.cpp
  group src/source/lib/rs24g_bin_core
    source/lib/rs24g_bin_core/: rs24g_bin.c rs24g_code2.c rs24g_code2_local.c
  group src/source/lib/rs24g_bin_platform
    source/lib/rs24g_bin_platform/: rs24g_bin_interface.c
  group src/source/lib/rs24g_ctl_core
    source/lib/rs24g_ctl_core/: rs24g_ctl_2rx.c rs24g_ctl_base.c rs24g_ctl_common.c rs24g_ctl_distance.c rs24g_ctl_fifo.c rs24g_ctl_motion.c rs24g_ctl_sensor_ctl_type.c rs24g_ctl_setup.c
  group src/source/lib/rs24g_ctl_core/sc1233
    source/lib/rs24g_ctl_core/sc1233/: rs24g_ctl_sc1233_version.c
  group src/source/lib/rs24g_ctl_setup_core
    source/lib/rs24g_ctl_setup_core/: rs24g_ctl_setup_base.c rs24g_ctl_setup_range.c setup_2d.c setup_bin.c setup_common.c setup_distance.c setup_distance_wide.c setup_fifo.c setup_fifo_fft_1rx_wide.c setup_fifo_fft_2rx_wide.c setup_fifo_iq_1rx_wide.c setup_fifo_iq_2rx_wide.c setup_motion.c setup_motion_wide.c
  group src/source/lib/rs24g_ctl_setup_core/sc1233
    source/lib/rs24g_ctl_setup_core/sc1233/: rs24g_ctl_setup_sc1233_version.c
  group src/source/lib/rs_ctl_dev
    source/lib/rs_ctl_dev/: rs_ctl_dev.c
  group src/source/lib/rs_ctl_dev_evk
    source/lib/rs_ctl_dev_evk/: rs_ctl_dev_evk.cpp rs_ftdi.cpp
  group src/source/lib/rs_ctl_dev_poc
    source/lib/rs_ctl_dev_poc/: rs_ctl_dev_poc.cpp rs_i2c.cpp
  group src/source/lib/rs_ctl_lib
    source/lib/rs_ctl_lib/: rs_ctl_cmd.c rs_ctl_cmd_sc1233.c rs_ctl_data.c rs_ctl_op.c rs_ctl_sensor_data.c
  group src/source/lib/rs_platform
    source/lib/rs_platform/: rs_mutex.cpp rs_sleep.cpp
  group src/STM32F0xx_HAL_Driver/Src
    STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_timebase_rtc_alarm_template.c stm32f0xx_hal_timebase_rtc_wakeup_template.c stm32f0xx_hal_timebase_tim_template.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_usart_ex.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_usb.c stm32f0xx_ll_utils.c
  group src/user/Src
    user/Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c system_stm32f0xx.c
